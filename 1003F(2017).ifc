Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-03-15T13:59:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Mar 15 13:59:36 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{78DF2BE6-9C2F-4839-AB44-18B3667F7737}\ifc * Database version: 5507 * Database creation date: Fri Mar 15 13:59:35 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Mar 15 13:59:36 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Mar 15 13:59:36 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1003F Washbasin faucet for summer house, 1003F(2017):1003F Washbasin faucet for summer house:340203
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - FaucetNominalDepth: 144 mm; FaucetNominalHeight: 147 mm; FaucetNominalWidth: 58 mm; HeaterNominalDepth: 213 mm; HeaterNominalHeight: 418.2 mm; HeaterNominalWidth: 255 mm; InletConnectionSize: 10 mm; Projection: 107 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1003F(2017); ConvergoRefNr: 0087-1803-0001-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for wash basin and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with disinfection wash proof Bidetta shower set; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 07/03/2019
Type - Green Building Properties(Type) - Customs Code: 84818011; EAN Number: 6414150078538; EN Standard: EN 817; LVI Number: 6110193; Noise Class: I (ISO 3822); NRF Number: 4200167; RSK Number: 8277678; VVS Number: 701645604
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1003F; Catalog Drawing URL: http://static.oras.com/catdrw/1003F; Class: Single lever, low pressure; Dimension Drawing URL: http://static.oras.com/dimdrw/1003F; FDV Document URL: http://www.oras.com/datasheet/1003F/en/fdv; Group: Washbasin faucets; Long Marketing: Washbasin faucet for summer house and water heater. Fixed spout and aerator. Maximum flow-rate 5 l/min. Due to the heating of water, water dripping from the aerator is a feature of this product and should not prevented. The aerator may not be changed or supplemented with additional components. Plug in, unpressurized water heater, 5 l. Easy to install. Range of use +35° – 85°C (recommendation + 65°C). In order to prevent frost damage, the faucet and the water heater must be emptied. This water heater is only allowed to operate with the original Oras summer house faucet. Warning! Water heater can heat the water up to +85°C. Beware of the instant scalding hot water from the faucet. The faucet and the water heater should not be installed separately.; Manufacturer: Oras; Market: INT;DNK;EST;FIN;LVA;LTU;NOR;POL;RUS;SWE;UKR; Model: 1003F Washbasin faucet for summer house; Name_en: 1003F Washbasin faucet for summer house; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: n/a; Package Weight: 5.42 kg; Product Code: 1003F; Product Datasheet: http://www.oras.com/datasheet/1003F/en; Product Family: Oras Safira; Product Image URL: http://static.oras.com/image/1003F; Product URL: http://static.oras.com/1003F; Type Name: 1003F Washbasin faucet for summer house
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - HWFU: 0; Installation and Maintenance: http://static.oras.com/manual/1003F; Installation Type: Deck mounted; Max. Hot Water Supply: 80 kg/K/s3; Pipes: Flexible inlet pipe(s); Spare Parts: http://static.oras.com/sp/1003F; Spout Type: Fixed spout
Type - Other(Type) - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1003F(2017); Features: Single lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1003F; Name: 1003F Washbasin faucet for summer house; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet: 58x144x147 mm / Heater: 255x213x418 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1003F; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1003F Washbasin faucet for summer house
Constraints - DistanceX-Axis: 200 mm; DistanceY-Axis: 100 mm; FaucetDefaultElevation: 900 mm; HeaterDefaultElevation: 200 mm; HeaterVisibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.28685 m2; Volume: 0.0237776 m3
Identity Data - Mark: 24
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water,Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1003F(2017): 1003F Washbasin faucet for summer house; Family and Type: 1003F(2017): 1003F Washbasin faucet for summer house; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1003F(2017): 1003F Washbasin faucet for summer house; Type Id: 1003F(2017): 1003F Washbasin faucet for summer house; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
